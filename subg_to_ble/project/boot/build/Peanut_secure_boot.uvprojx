# Keil uVision project Peanut_secure_boot.uvprojx, settings and files
target nrf52810_xxaa_s112 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52810_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x30000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: boot +hex
  AfterMake: User.bat
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_XH_5102 BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_SOFT NRF52810_XXAA NRF52_PAN_74 NRF_DFU_SETTINGS_VERSION=2 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=6 S112 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION __HEAP_SIZE=0 __STACK_SIZE=2048 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  c misc: --reduce_paths
  c include: ..\config;..\..\..\nrfSDK\components\ble\common;..\boards;..\..\..\nrfSDK\components\libraries\atomic;..\..\..\nrfSDK\components\libraries\atomic_fifo;..\..\..\nrfSDK\components\libraries\balloc;..\..\..\nrfSDK\components\libraries\bootloader;..\..\..\nrfSDK\components\libraries\bootloader\ble_dfu;..\..\..\nrfSDK\components\libraries\bootloader\dfu;..\..\..\nrfSDK\components\libraries\crc32;..\..\..\nrfSDK\components\libraries\crypto;..\..\..\nrfSDK\components\libraries\crypto\backend\cc310;..\..\..\nrfSDK\components\libraries\crypto\backend\cc310_bl;..\..\..\nrfSDK\components\libraries\crypto\backend\cifra;..\..\..\nrfSDK\components\libraries\crypto\backend\mbedtls;..\..\..\nrfSDK\components\libraries\crypto\backend\micro_ecc;..\..\..\nrfSDK\components\libraries\crypto\backend\nrf_hw;..\..\..\nrfSDK\components\libraries\crypto\backend\nrf_sw;..\..\..\nrfSDK\components\libraries\crypto\backend\oberon;..\..\..\nrfSDK\components\libraries\crypto\backend\optiga;..\..\..\nrfSDK\components\libraries\delay;..\..\..\nrfSDK\components\libraries\experimental_section_vars;..\..\..\nrfSDK\components\libraries\fstorage;..\..\..\nrfSDK\components\libraries\log;..\..\..\nrfSDK\components\libraries\log\src;..\..\..\nrfSDK\components\libraries\mem_manager;..\..\..\nrfSDK\components\libraries\memobj;..\..\..\nrfSDK\components\libraries\queue;..\..\..\nrfSDK\components\libraries\ringbuf;..\..\..\nrfSDK\components\libraries\scheduler;..\..\..\nrfSDK\components\libraries\sha256;..\..\..\nrfSDK\components\libraries\stack_info;..\..\..\nrfSDK\components\libraries\strerror;..\..\..\nrfSDK\components\libraries\svc;..\..\..\nrfSDK\components\libraries\util;..\..\..\nrfSDK\components\softdevice\common;..\..\..\nrfSDK\components\softdevice\s112\headers;..\..\..\nrfSDK\components\softdevice\s112\headers\nrf52;..\..\..\nrfSDK\external\fprintf;..\..\..\nrfSDK\external\micro-ecc\micro-ecc;..\..\..\nrfSDK\external\nano-pb;..\..\..\nrfSDK\external\nrf_oberon;..\..\..\nrfSDK\external\nrf_oberon\include;..\..\..\nrfSDK\integration\nrfx;..\..\..\nrfSDK\modules\nrfx;..\..\..\nrfSDK\modules\nrfx\hal;..\..\..\nrfSDK\modules\nrfx\mdk;..\boards;..\..\..\nrfSDK\components\libraries\timer
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_SOFT NRF52810_XXAA NRF52_PAN_74 NRF_DFU_SETTINGS_VERSION=2 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=6 S112 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION __HEAP_SIZE=0 __STACK_SIZE=2048 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_DFU_SETTINGS_VERSION=2,-DNRF_DFU_SVCI_ENABLED,-DNRF_SD_BLE_API_VERSION=6,-DS132,-DSOFTDEVICE_PRESENT,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-D__HEAP_SIZE=0,-DuECC_ENABLE_VLI_API=0,-DuECC_OPTIMIZATION_LEVEL=3,-DuECC_SQUARE_FUNC=0,-DuECC_SUPPORT_COMPRESSED_POINT=0,-DuECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm include: ..\..\config;..\..\..\..\..\components\ble\common;..\..\..\..\..\components\boards;..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\components\libraries\bootloader;..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\components\libraries\crypto\backend\cc310;..\..\..\..\..\components\libraries\crypto\backend\cc310_bl;..\..\..\..\..\components\libraries\crypto\backend\cifra;..\..\..\..\..\components\libraries\crypto\backend\mbedtls;..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\components\libraries\crypto\backend\nrf_hw;..\..\..\..\..\components\libraries\crypto\backend\nrf_sw;..\..\..\..\..\components\libraries\crypto\backend\oberon;..\..\..\..\..\components\libraries\crypto\backend\optiga;..\..\..\..\..\components\libraries\delay;..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\components\libraries\log;..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\components\libraries\queue;..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\components\libraries\sha256;..\..\..\..\..\components\libraries\stack_info;..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\components\libraries\svc;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\softdevice\common;..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..;..\..\..\..\..\external\fprintf;..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\external\nano-pb;..\..\..\..\..\external\nrf_oberon;..\..\..\..\..\external\nrf_oberon\include;..\..\..\..\..\integration\nrfx;..\..\..\..\..\modules\nrfx;..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x28000 size 0x6000
  memory RVCT9: RAM 0x20002390 size 0x3c70
  link misc: --diag_suppress 6330
  group Application
    ../config/: sdk_config.h
    ../src/: dfu_public_key.c main.c
  group Board Definition
    ../boards/: boards.c
  group nRF_BLE
    ../../../nrfSDK/components/ble/common/: ble_srv_common.c
  group nRF_Bootloader
    ../../../nrfSDK/components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_final.c nrf_bootloader_dfu_timers.c nrf_bootloader_fw_activation.c nrf_bootloader_info.c nrf_bootloader_wdt.c
  group nRF_Crypto
    ../../../nrfSDK/components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group nRF_Crypto backend Oberon
    ../../../nrfSDK/components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto backend nRF sw
    ../../../nrfSDK/components/libraries/crypto/backend/nrf_sw/: nrf_sw_backend_hash.c
  group nRF_Crypto backend uECC
    ../../../nrfSDK/components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group nRF_DFU
    ../../../nrfSDK/components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_settings_svci.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
    ../../../nrfSDK/components/libraries/bootloader/ble_dfu/: nrf_dfu_ble.c
  group nRF_Drivers
    ../../../nrfSDK/modules/nrfx/hal/: nrf_nvmc.c
    ../../../nrfSDK/modules/nrfx/soc/: nrfx_atomic.c
  group nRF_Libraries
    ../../../nrfSDK/components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../nrfSDK/components/libraries/scheduler/: app_scheduler.c
    ../../../nrfSDK/components/libraries/crc32/: crc32.c
    ../../../nrfSDK/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../nrfSDK/components/libraries/atomic/: nrf_atomic.c
    ../../../nrfSDK/components/libraries/balloc/: nrf_balloc.c
    ../../../nrfSDK/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../../../nrfSDK/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../nrfSDK/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../nrfSDK/components/libraries/strerror/: nrf_strerror.c
    ../../../nrfSDK/components/libraries/sha256/: sha256.c
  group nRF_Oberon_Crypto
    ../../../nrfSDK/external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: oberon_2.0.7.lib
  group nRF_SVC
    ../../../nrfSDK/components/libraries/bootloader/dfu/: nrf_dfu_svci.c nrf_dfu_svci_handler.c
    ../../../nrfSDK/components/libraries/svc/: nrf_svc_handler.c
  group nRF_SoftDevice
    ../../../nrfSDK/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_micro-ecc
    ../../../nrfSDK/external/micro-ecc/nrf52nf_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nano-pb
    ../../../nrfSDK/external/nano-pb/: pb_common.c pb_decode.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.24.1
