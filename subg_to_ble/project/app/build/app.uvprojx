# Keil uVision project app.uvprojx, settings and files
target nrf52810_xxaa (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52810_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x30000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: User.bat
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: xUSER_DEBUG xDEBUG BOARD_XH_5102 xBOARD_XH601 BL_SETTINGS_ACCESS_ONLY  NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_SOFT NRF52810_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=6 S112 SOFTDEVICE_PRESENT SWI_DISABLE0 __HEAP_SIZE=2048 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\config;..\..\..\nrfSDK\components;..\..\..\nrfSDK\components\ble\ble_advertising;..\..\..\nrfSDK\components\ble\ble_db_discovery;..\..\..\nrfSDK\components\ble\ble_link_ctx_manager;..\..\..\nrfSDK\components\ble\ble_racp;..\..\..\nrfSDK\components\ble\ble_services\ble_dfu;..\..\..\nrfSDK\components\ble\common;..\..\..\nrfSDK\components\ble\nrf_ble_gatt;..\..\..\nrfSDK\components\ble\nrf_ble_qwr;..\..\..\nrfSDK\components\ble\peer_manager;..\..\..\nrfSDK\components\libraries\atomic;..\..\..\nrfSDK\components\libraries\atomic_fifo;..\..\..\nrfSDK\components\libraries\atomic_flags;..\..\..\nrfSDK\components\libraries\balloc;..\..\..\nrfSDK\components\libraries\bootloader\ble_dfu;..\..\..\nrfSDK\components\libraries\crc16;..\..\..\nrfSDK\components\libraries\crc32;..\..\..\nrfSDK\components\libraries\crypto;..\..\..\nrfSDK\components\libraries\delay;..\..\..\nrfSDK\components\libraries\ecc;..\..\..\nrfSDK\components\libraries\experimental_section_vars;..\..\..\nrfSDK\components\libraries\experimental_task_manager;..\..\..\nrfSDK\components\libraries\fds;..\..\..\nrfSDK\components\libraries\fifo;..\..\..\nrfSDK\components\libraries\fstorage;..\..\..\nrfSDK\components\libraries\gfx;..\..\..\nrfSDK\components\libraries\gpiote;..\..\..\nrfSDK\components\libraries\hardfault;..\..\..\nrfSDK\components\libraries\hci;..\..\..\nrfSDK\components\libraries\led_softblink;..\..\..\nrfSDK\components\libraries\log;..\..\..\nrfSDK\components\libraries\log\src;..\..\..\nrfSDK\components\libraries\low_power_pwm;..\..\..\nrfSDK\components\libraries\mem_manager;..\..\..\nrfSDK\components\libraries\memobj;..\..\..\nrfSDK\components\libraries\mpu;..\..\..\nrfSDK\components\libraries\mutex;..\..\..\nrfSDK\components\libraries\pwm;..\..\..\nrfSDK\components\libraries\pwr_mgmt;..\..\..\nrfSDK\components\libraries\queue;..\..\..\nrfSDK\components\libraries\ringbuf;..\..\..\nrfSDK\components\libraries\scheduler;..\..\..\nrfSDK\components\libraries\slip;..\..\..\nrfSDK\components\libraries\sortlist;..\..\..\nrfSDK\components\libraries\stack_guard;..\..\..\nrfSDK\components\libraries\strerror;..\..\..\nrfSDK\components\libraries\svc;..\..\..\nrfSDK\components\libraries\timer;..\..\..\nrfSDK\components\libraries\uart;..\..\..\nrfSDK\components\libraries\util;..\..\..\nrfSDK\components\softdevice\common;..\..\..\nrfSDK\components\softdevice\s112\headers;..\..\..\nrfSDK\components\softdevice\s112\headers\nrf52;..\..\..\nrfSDK\external\fprintf;..\..\..\nrfSDK\external\segger_rtt;..\..\..\nrfSDK\external\utf_converter;..\..\..\nrfSDK\integration\nrfx;..\..\..\nrfSDK\integration\nrfx\legacy;..\..\..\nrfSDK\modules\nrfx;..\..\..\nrfSDK\modules\nrfx\drivers\include;..\..\..\nrfSDK\modules\nrfx\hal;..\..\..\nrfSDK\modules\nrfx\mdk;..\..\..\userKit\assert;..\..\..\userKit\fifo;..\..\..\userKit\heap;..\..\..\userKit\log;..\..\..\userKit\utils;..\..\..\userKit\delay;..\..\..\nrfSDK\components\libraries\bootloader;..\..\..\nrfSDK\components\libraries\bootloader\dfu;..\..\..\nrfSDK\components\libraries\fds;..\..\..\nrfSDK\components\libraries\fstorage;..\..\..\boards;..\..\..\periph\motor;..\..\..\periph\led;..\inc;..\..\..\nrfSDK\components\ble\ble_services\ble_bas;..\..\..\periph\onChip;..\..\..\periph\rf69;..\..\..\lib\pump\ble_services\ble_ips;..\..\..\lib\pump\encrypt;..\..\..\nrfSDK\components\ble\ble_services\ble_nus;..\..\..\periph\buzzer
  asm define: BL_SETTINGS_ACCESS_ONLY  NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_SOFT NRF52810_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=6 S112 SOFTDEVICE_PRESENT SWI_DISABLE0 __HEAP_SIZE=2048 __STACK_SIZE=2048
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=6,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_link_ctx_manager;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\atomic_flags;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\experimental_task_manager;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gfx;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mpu;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sdcard;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\spi_mngr;..\..\..\..\..\..\components\libraries\stack_guard;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\components\libraries\twi_sensor;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\..\..\..\components\nfc\ndef\connection_handover\common;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\..\..\..\components\nfc\ndef\generic\message;..\..\..\..\..\..\components\nfc\ndef\generic\record;..\..\..\..\..\..\components\nfc\ndef\launchapp;..\..\..\..\..\..\components\nfc\ndef\parser\message;..\..\..\..\..\..\components\nfc\ndef\parser\record;..\..\..\..\..\..\components\nfc\ndef\text;..\..\..\..\..\..\components\nfc\ndef\uri;..\..\..\..\..\..\components\nfc\t2t_lib;..\..\..\..\..\..\components\nfc\t2t_parser;..\..\..\..\..\..\components\nfc\t4t_lib;..\..\..\..\..\..\components\nfc\t4t_parser\apdu;..\..\..\..\..\..\components\nfc\t4t_parser\cc_file;..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\..\..\..\components\nfc\t4t_parser\tlv;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\external\utf_converter;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x19000 size 0xf000
  memory RVCT9: RAM 0x20002b00 size 0x3500
  link misc: --diag_suppress 6330
  group Application
    ../config/: sdk_config.h kit_config.h
    ../src/: app_sys.c app_ble.c app_battery.c app_aps.c app_indication.c app_subg.c main.c app_factory.c app_config.c
  group Board Definition
    ../../../boards/: boards.h bd_xh601_config.h
  group nRF_BLE
    ../../../nrfSDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../nrfSDK/components/ble/ble_advertising/: ble_advertising.c
    ../../../nrfSDK/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../../nrfSDK/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../nrfSDK/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_DFU
    ../../../nrfSDK/components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_unbonded.c
  group nRF_BLE_Services
    ../../../nrfSDK/components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../nrfSDK/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../../../nrfSDK/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_spi.c
    ../../../nrfSDK/modules/nrfx/soc/: nrfx_atomic.c
    ../../../nrfSDK/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_spim.c nrfx_timer.c nrfx_wdt.c nrfx_pwm.c nrfx_saadc.c nrfx_power.c
    ../../../nrfSDK/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../nrfSDK/components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c app_error_weak.c app_error_handler_keil.c
    ../../../nrfSDK/components/libraries/timer/: app_timer.c
    ../../../nrfSDK/components/libraries/hardfault/: hardfault_implementation.c
    ../../../nrfSDK/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../nrfSDK/components/libraries/atomic_flags/: nrf_atflags.c
    ../../../nrfSDK/components/libraries/atomic/: nrf_atomic.c
    ../../../nrfSDK/components/libraries/balloc/: nrf_balloc.c
    ../../../nrfSDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../nrfSDK/components/libraries/memobj/: nrf_memobj.c
    ../../../nrfSDK/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../nrfSDK/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../nrfSDK/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../nrfSDK/components/libraries/strerror/: nrf_strerror.c
    ../../../nrfSDK/components/libraries/fstorage/: nrf_fstorage_sd.c nrf_fstorage.c
    ../../../nrfSDK/components/libraries/fifo/: app_fifo.c
  group nRF_Log
    ../../../nrfSDK/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_SVC
    ../../../nrfSDK/components/libraries/bootloader/dfu/: nrf_dfu_svci.c
  group nRF_Segger_RTT
    ../../../nrfSDK/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../nrfSDK/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group User Kit
    ../../../userKit/fifo/: kit_fifo.c
    ../../../userKit/delay/: kit_delay.c
    ../../../userKit/utils/: kit_utils.c
    ../../../userKit/log/: kit_log.c
  group User Drivers
    ../../../periph/led/: led.c
    ../../../periph/motor/: motor.c
    ../../../periph/onChip/: ocp.c
    ../../../periph/rf69/: rf69.c
    ../../../periph/buzzer/: buzzer.c
  group User Lib
    ../../../lib/pump/ble_services/ble_ips/: ble_ips.c
    ../../../lib/pump/encrypt/: 4b6b.c manchester.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.24.1
